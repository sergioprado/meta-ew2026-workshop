IMAGE_INSTALL:append = "\
    torq-runtime \
    kernel-module-syna_npu \
    android-tools-adbd \
    python3-pip \
    python3-venv \
    python3-numpy \
    python3-pillow \
    python3-ensurepip \
"
