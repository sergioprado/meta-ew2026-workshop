SOTA_POLLING_SEC = "5"
